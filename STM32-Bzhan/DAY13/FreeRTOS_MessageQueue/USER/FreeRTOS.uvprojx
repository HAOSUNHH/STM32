# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\DHT;..\HARDWARE\KEY;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE\RTC;..\HARDWARE\IWDG;..\HARDWARE\BEEP;..\HARDWARE\OLED;..\HARDWARE\PAJ7620U2;..\HARDWARE\ADC;..\HARDWARE\BLE;..\HARDWARE\KEYBOARD;..\HARDWARE\EEPROM;..\HARDWARE\SR04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c menu.c
  group HARDWARE
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT/: dht11.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/OLED/: oled.c bmp.c
    ../HARDWARE/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BLE/: ble.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/SR04/: sr04.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ./: system_stm32f4xx.c stm32f4xx_it.c
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_adc.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
